# Keil uVision project STM32_mini.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_mini +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\User;.\FwLib\inc;.\Hardware;.\Gizwits;.\App
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FwLib
    ./FwLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ./Hardware/: Led.c Uart.c I2C.c Delay.c FT6336U.c Exit.c I2C_HW.c FT.c Uart2.c ESP8266_Sta.c timer.c Lcd.c KEY.c Adc.c
  group IOT_Led
    ./Gizwits/: gizwits_product.c gizwits_protocol.c common.c dataPointTools.c ringbuffer.c
  group App
    ./App/: App.c
